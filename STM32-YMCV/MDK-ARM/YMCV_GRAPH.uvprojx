# Keil uVision project YMCV_GRAPH.uvprojx, settings and files
target YMCV_GRAPH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: YMCV_GRAPH +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../CONFIG;../GRAPH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c dcmi.c dma.c fsmc.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Basic
    ../GRAPH/USART/: printf.c
    ../GRAPH/DELAY/: delay.c
    ../GRAPH/OV5640/: ov5640.c sccb.c
    ../GRAPH/LED/: led.c
    ../GRAPH/LCD/: lcd_cfg.c
  group CONFIG
    ../CONFIG/CAMRERA/: camera.c
    ../CONFIG/MALLOC/: MemDbg.c
  group YMCV-OPobj
    ../YMCV/OPOBJ/: YMCV_Creat.c YMCV_Free.c
  group YMCV-Core
    ../YMCV/CORE/: YMCV-Stm32F407.lib
  group YMCV-Debug
    ../YMCV/DEBUG/: YMCV_Debug.c
  group YMCV-Config
    ../YMCV/CONFIG/: YMCV_Mem.c
  group LCD
    ../LCD/: LCD.c
  group ImageSource
    ../ImageSource/: linglong00b_gray.c linglong00b.c xgmm_gray.c mm02_gray.c mnumber0_9_gray.c mm02.c tuxin02_gray.c xunxian03.c luojiuchuan_112x112_Gray.c gujia1_gray.c ctcut01_gray.c sleft1_sright1_gray.c luojiuchuan2_gray.c wutu2_gray.c house2.c huochairen_gray.c aprilTag2_gray.c DataMatrix_gray.c qrcode_gray.c bar_gray.c
software components: CMSIS:CORE 4.3.0
